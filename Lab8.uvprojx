# Keil uVision project Lab8.uvprojx, settings and files
target BaseFrameworkTarget (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Main
    ./Source/: main.c
  group Source
    ./Source/: EventCheckers.c TemplateFSM.c ES_ShortTimer.c ADMulti.c ADService.c ES_Queue.c main.c PWMmodule.c TemplateService.c SPIService.c ActionService.c MotorActionsModule.c
  group Headers
    ./Headers/: uartstdio.h Bin_Const.h BITDEFS.H ES_CheckEvents.h ES_Configure.h ES_DeferRecall.h ES_Events.h ES_Framework.h ES_General.h ES_LookupTables.h ES_Port.h ES_PostList.h ES_PriorTables.h ES_Queue.h ES_ServiceHeaders.h ES_Timers.h ES_Types.h EventCheckers.h termio.h TestHarnessService0.h ES_ShortTimer.h ADMulti.h ADService.h PWMmodule.h TemplateFSM.h TemplateService.h SPIService.h ActionService.h MotorActionsModule.h
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
  group Startup
    ./StartUp/: startup_rvmdk.S
  group Framework
    ./Source/: ES_CheckEvents.c ES_DeferRecall.c ES_Framework.c ES_LookupTables.c ES_Port.c ES_PostList.c ES_Queue.c ES_Timers.c retarget.c termio.c uartstdio.c
target SPITarget (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: as above
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
